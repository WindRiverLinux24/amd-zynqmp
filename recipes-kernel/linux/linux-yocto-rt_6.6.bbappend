require linux-yocto-amd-zynqmp.inc

KBRANCH:amd-zynqmp  = "v6.6/standard/preempt-rt/sdkv6.6/xlnx-soc"
