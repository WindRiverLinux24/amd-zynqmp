require linux-yocto-amd-zynqmp.inc

KBRANCH:amd-zynqmp = "v6.6/standard/sdkv6.6/xlnx-soc"
